# Keil uVision project Transceiver.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 IP Core Oregano Systems
  cpu: IRAM(0-0x7F) XRAM(0-0xFFFF) IROM(0-0xFFF) CLOCK(12000000)
  output: Transceiver +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Delay.c I2C.c LCD.c main_transmitter.c tmp100.c KXTJ9.c NVRF.c case.h fftmisc.c fourierf.c ddcmath.h fourier.h
